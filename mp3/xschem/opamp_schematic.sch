v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 70 90 70 100 {
lab=#net1}
N 70 100 340 100 {
lab=#net1}
N 340 90 340 100 {
lab=#net1}
N 70 20 70 30 {
lab=#net2}
N 70 20 340 20 {
lab=#net2}
N 340 20 340 30 {
lab=#net2}
N 160 20 160 30 {
lab=#net2}
N 250 20 250 30 {
lab=#net2}
N 160 90 160 100 {
lab=#net1}
N 250 90 250 100 {
lab=#net1}
N 20 60 40 60 {
lab=#net3}
N 20 60 130 60 {
lab=#net3}
N 130 60 220 60 {
lab=#net3}
N 220 60 310 60 {
lab=#net3}
N 740 90 740 100 {
lab=#net4}
N 470 100 740 100 {
lab=#net4}
N 470 90 470 100 {
lab=#net4}
N 740 20 740 30 {
lab=#net5}
N 470 20 740 20 {
lab=#net5}
N 470 20 470 30 {
lab=#net5}
N 650 20 650 30 {
lab=#net5}
N 560 20 560 30 {
lab=#net5}
N 650 90 650 100 {
lab=#net4}
N 560 90 560 100 {
lab=#net4}
N 770 60 790 60 {
lab=#net6}
N 680 60 790 60 {
lab=#net6}
N 590 60 680 60 {
lab=#net6}
N 500 60 590 60 {
lab=#net6}
N 70 230 70 240 {
lab=#net7}
N 70 240 340 240 {
lab=#net7}
N 340 230 340 240 {
lab=#net7}
N 70 160 70 170 {
lab=#net8}
N 70 160 340 160 {
lab=#net8}
N 340 160 340 170 {
lab=#net8}
N 160 160 160 170 {
lab=#net8}
N 250 160 250 170 {
lab=#net8}
N 160 230 160 240 {
lab=#net7}
N 250 230 250 240 {
lab=#net7}
N 20 200 40 200 {
lab=#net9}
N 20 200 130 200 {
lab=#net9}
N 130 200 220 200 {
lab=#net9}
N 220 200 310 200 {
lab=#net9}
N 470 230 470 240 {
lab=#net7}
N 470 240 740 240 {
lab=#net7}
N 740 230 740 240 {
lab=#net7}
N 470 160 470 170 {
lab=#net8}
N 470 160 740 160 {
lab=#net8}
N 740 160 740 170 {
lab=#net8}
N 560 160 560 170 {
lab=#net8}
N 650 160 650 170 {
lab=#net8}
N 560 230 560 240 {
lab=#net7}
N 650 230 650 240 {
lab=#net7}
N 530 200 620 200 {
lab=#net9}
N 620 200 710 200 {
lab=#net9}
N 440 200 530 200 {
lab=#net9}
N 310 200 440 200 {
lab=#net9}
N 340 160 470 160 {
lab=#net8}
N 340 240 470 240 {
lab=#net7}
N 1150 100 1150 110 {
lab=#net10}
N 1150 110 1420 110 {
lab=#net10}
N 1420 100 1420 110 {
lab=#net10}
N 1150 30 1150 40 {
lab=#net11}
N 1150 30 1420 30 {
lab=#net11}
N 1420 30 1420 40 {
lab=#net11}
N 1240 30 1240 40 {
lab=#net11}
N 1330 30 1330 40 {
lab=#net11}
N 1240 100 1240 110 {
lab=#net10}
N 1330 100 1330 110 {
lab=#net10}
N 1100 70 1120 70 {
lab=#net12}
N 1100 70 1210 70 {
lab=#net12}
N 1210 70 1300 70 {
lab=#net12}
N 1300 70 1390 70 {
lab=#net12}
N 1550 30 1550 40 {
lab=#net13}
N 1550 30 1820 30 {
lab=#net13}
N 1820 30 1820 40 {
lab=#net13}
N 1550 100 1550 110 {
lab=#net14}
N 1550 110 1820 110 {
lab=#net14}
N 1820 100 1820 110 {
lab=#net14}
N 1640 100 1640 110 {
lab=#net14}
N 1730 100 1730 110 {
lab=#net14}
N 1640 30 1640 40 {
lab=#net13}
N 1730 30 1730 40 {
lab=#net13}
N 1610 70 1700 70 {
lab=#net12}
N 1700 70 1790 70 {
lab=#net12}
N 1150 230 1150 240 {
lab=#net15}
N 1150 240 1420 240 {
lab=#net15}
N 1420 230 1420 240 {
lab=#net15}
N 1150 160 1150 170 {
lab=#net16}
N 1150 160 1420 160 {
lab=#net16}
N 1420 160 1420 170 {
lab=#net16}
N 1240 160 1240 170 {
lab=#net16}
N 1330 160 1330 170 {
lab=#net16}
N 1240 230 1240 240 {
lab=#net15}
N 1330 230 1330 240 {
lab=#net15}
N 1100 200 1120 200 {
lab=#net17}
N 1100 200 1210 200 {
lab=#net17}
N 1210 200 1300 200 {
lab=#net17}
N 1300 200 1390 200 {
lab=#net17}
N 1550 160 1550 170 {
lab=#net18}
N 1550 160 1820 160 {
lab=#net18}
N 1820 160 1820 170 {
lab=#net18}
N 1550 230 1550 240 {
lab=#net19}
N 1550 240 1820 240 {
lab=#net19}
N 1820 230 1820 240 {
lab=#net19}
N 1640 230 1640 240 {
lab=#net19}
N 1730 230 1730 240 {
lab=#net19}
N 1640 160 1640 170 {
lab=#net18}
N 1730 160 1730 170 {
lab=#net18}
N 1610 200 1700 200 {
lab=#net17}
N 1700 200 1790 200 {
lab=#net17}
N 1520 70 1610 70 {
lab=#net12}
N 1390 70 1520 70 {
lab=#net12}
N 1520 200 1610 200 {
lab=#net17}
N 1390 200 1520 200 {
lab=#net17}
N 1150 -70 1150 -60 {
lab=#net20}
N 1150 -60 1420 -60 {
lab=#net20}
N 1420 -70 1420 -60 {
lab=#net20}
N 1150 -140 1150 -130 {
lab=#net21}
N 1150 -140 1420 -140 {
lab=#net21}
N 1420 -140 1420 -130 {
lab=#net21}
N 1240 -140 1240 -130 {
lab=#net21}
N 1330 -140 1330 -130 {
lab=#net21}
N 1240 -70 1240 -60 {
lab=#net20}
N 1330 -70 1330 -60 {
lab=#net20}
N 1150 -200 1150 -190 {
lab=#net22}
N 1150 -190 1420 -190 {
lab=#net22}
N 1420 -200 1420 -190 {
lab=#net22}
N 1150 -270 1150 -260 {
lab=#net23}
N 1150 -270 1420 -270 {
lab=#net23}
N 1420 -270 1420 -260 {
lab=#net23}
N 1240 -200 1240 -190 {
lab=#net22}
N 1330 -200 1330 -190 {
lab=#net22}
N 1240 -270 1240 -260 {
lab=#net23}
N 1330 -270 1330 -260 {
lab=#net23}
N 1550 -70 1550 -60 {
lab=#net24}
N 1550 -60 1820 -60 {
lab=#net24}
N 1820 -70 1820 -60 {
lab=#net24}
N 1640 -70 1640 -60 {
lab=#net24}
N 1730 -70 1730 -60 {
lab=#net24}
N 1550 -140 1550 -130 {
lab=#net25}
N 1550 -140 1820 -140 {
lab=#net25}
N 1820 -140 1820 -130 {
lab=#net25}
N 1640 -140 1640 -130 {
lab=#net25}
N 1730 -140 1730 -130 {
lab=#net25}
N 1550 -200 1550 -190 {
lab=#net26}
N 1550 -190 1820 -190 {
lab=#net26}
N 1820 -200 1820 -190 {
lab=#net26}
N 1550 -270 1550 -260 {
lab=#net27}
N 1550 -270 1820 -270 {
lab=#net27}
N 1820 -270 1820 -260 {
lab=#net27}
N 1640 -270 1640 -260 {
lab=#net27}
N 1730 -270 1730 -260 {
lab=#net27}
N 1640 -200 1640 -190 {
lab=#net26}
N 1730 -200 1730 -190 {
lab=#net26}
N 1700 -230 1790 -230 {
lab=#net28}
N 1610 -230 1700 -230 {
lab=#net28}
N 1520 -230 1610 -230 {
lab=#net28}
N 1390 -230 1520 -230 {
lab=#net28}
N 1300 -230 1390 -230 {
lab=#net28}
N 1210 -230 1300 -230 {
lab=#net28}
N 1120 -230 1210 -230 {
lab=#net28}
N 1100 -230 1120 -230 {
lab=#net28}
N 1700 -100 1790 -100 {
lab=#net29}
N 1610 -100 1700 -100 {
lab=#net29}
N 1520 -100 1610 -100 {
lab=#net29}
N 1390 -100 1520 -100 {
lab=#net29}
N 1300 -100 1390 -100 {
lab=#net29}
N 1210 -100 1300 -100 {
lab=#net29}
N 1120 -100 1210 -100 {
lab=#net29}
N 1100 -100 1120 -100 {
lab=#net29}
N 70 100 70 160 {}
N 740 100 740 160 {}
N 1150 -190 1150 -140 {}
N 1150 -60 1150 30 {}
N 1150 110 1150 160 {}
N 1820 -190 1820 -140 {}
N 1820 -60 1820 30 {}
N 1820 110 1820 160 {}
N 1420 240 1550 240 {}
N 1420 -270 1550 -270 {}
N 740 -160 1820 -160 {}
N 740 -160 740 20 {}
N 70 -170 1150 -170 {}
N 70 -170 70 20 {}
N 1060 200 1100 200 {}
N 1060 -10 1060 200 {}
N 1060 -10 1150 -10 {}
C {madvlsi/nmos3.sym} 70 60 0 0 {name=M1a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 160 60 0 0 {name=M1b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 60 0 0 {name=M1c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 340 60 0 0 {name=M1d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 740 60 0 1 {name=M2a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 650 60 0 1 {name=M2b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 560 60 0 1 {name=M2c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 470 60 0 1 {name=M2d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 70 200 0 0 {name=Mba
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 160 200 0 0 {name=Mbb
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 200 0 0 {name=Mbc
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 340 200 0 0 {name=Mbd
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 470 200 0 0 {name=Mbe
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 560 200 0 0 {name=Mbf
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 650 200 0 0 {name=Mbg
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 740 200 0 0 {name=Mbh
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1150 70 0 0 {name=M7a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1240 70 0 0 {name=M7b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1330 70 0 0 {name=M7c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1420 70 0 0 {name=M7d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1550 70 2 1 {name=M8a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1640 70 2 1 {name=M8b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1730 70 2 1 {name=M8c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1820 70 2 1 {name=M8d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1150 200 0 0 {name=M9a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1240 200 0 0 {name=M9b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1330 200 0 0 {name=M9c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1420 200 0 0 {name=M9d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1550 200 2 1 {name=M10a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1640 200 2 1 {name=M10b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1730 200 2 1 {name=M10c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1820 200 2 1 {name=M1
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1150 -100 0 0 {name=M5a
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1240 -100 0 0 {name=M5b
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1330 -100 0 0 {name=M5c
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1420 -100 0 0 {name=M5d
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1550 -100 0 0 {name=M6a
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1640 -100 0 0 {name=M6b
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1730 -100 0 0 {name=M6c
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1820 -100 0 0 {name=M6d
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1150 -230 0 0 {name=M3a
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1240 -230 0 0 {name=M3b
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1330 -230 0 0 {name=M3c
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1420 -230 0 0 {name=M3d
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1550 -230 0 0 {name=M4a
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1640 -230 0 0 {name=M4b
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1730 -230 0 0 {name=M4c
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1820 -230 0 0 {name=M4d
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
