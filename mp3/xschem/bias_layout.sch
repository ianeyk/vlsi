v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -2380 -390 -2380 -380 {
lab=VP}
N -2650 -390 -2380 -390 {
lab=VP}
N -2650 -390 -2650 -380 {
lab=VP}
N -2380 -320 -2380 -310 {
lab=Vbp}
N -2650 -310 -2380 -310 {
lab=Vbp}
N -2650 -320 -2650 -310 {
lab=Vbp}
N -2470 -390 -2470 -380 {
lab=VP}
N -2560 -390 -2560 -380 {
lab=VP}
N -2470 -320 -2470 -310 {
lab=Vbp}
N -2560 -320 -2560 -310 {
lab=Vbp}
N -470 90 -470 100 {
lab=#net1}
N -740 90 -740 100 {
lab=#net1}
N -470 20 -470 30 {
lab=#net2}
N -740 20 -740 30 {
lab=#net2}
N -560 90 -560 100 {
lab=#net1}
N -650 90 -650 100 {
lab=#net1}
N -560 20 -560 30 {
lab=#net2}
N -650 20 -650 30 {
lab=#net2}
N -710 60 -620 60 {
lab=#net1}
N -620 60 -530 60 {
lab=#net1}
N -530 60 -440 60 {
lab=#net1}
N -830 -390 -830 -380 {
lab=VP}
N -1530 20 -1530 30 {
lab=#net2}
N -1530 20 -1260 20 {
lab=#net2}
N -1260 20 -1260 30 {
lab=#net2}
N -1530 90 -1530 100 {
lab=#net3}
N -1530 100 -1260 100 {
lab=#net3}
N -1260 90 -1260 100 {
lab=#net3}
N -1440 20 -1440 30 {
lab=#net2}
N -1350 20 -1350 30 {
lab=#net2}
N -1440 90 -1440 100 {
lab=#net3}
N -1350 90 -1350 100 {
lab=#net3}
N -1380 60 -1290 60 {
lab=#net3}
N -1470 60 -1380 60 {
lab=#net3}
N -1560 60 -1470 60 {
lab=#net3}
N -1260 460 -1260 470 {
lab=#net3}
N -1530 460 -1260 460 {
lab=#net3}
N -1530 460 -1530 470 {
lab=#net3}
N -1260 530 -1260 540 {
lab=VN}
N -1530 540 -1260 540 {
lab=VN}
N -1530 530 -1530 540 {
lab=VN}
N -1350 530 -1350 540 {
lab=VN}
N -1440 530 -1440 540 {
lab=VN}
N -1350 460 -1350 470 {
lab=#net3}
N -1440 460 -1440 470 {
lab=#net3}
N -1410 500 -1320 500 {
lab=#net4}
N -1500 500 -1410 500 {
lab=#net4}
N -1320 500 -1230 500 {
lab=#net4}
N -1260 540 -1100 540 {
lab=VN}
N -1890 460 -1890 470 {
lab=#net4}
N -2160 460 -1890 460 {
lab=#net4}
N -2160 460 -2160 470 {
lab=#net4}
N -1890 530 -1890 540 {
lab=VN}
N -2160 540 -1890 540 {
lab=VN}
N -2160 530 -2160 540 {
lab=VN}
N -1980 530 -1980 540 {
lab=VN}
N -2070 530 -2070 540 {
lab=VN}
N -1980 460 -1980 470 {
lab=#net4}
N -2070 460 -2070 470 {
lab=#net4}
N -2040 500 -1950 500 {
lab=#net4}
N -2130 500 -2040 500 {
lab=#net4}
N -1890 -320 -1890 -310 {
lab=#net4}
N -2160 -310 -1890 -310 {
lab=#net4}
N -2160 -320 -2160 -310 {
lab=#net4}
N -1890 -390 -1890 -380 {
lab=VP}
N -2160 -390 -1890 -390 {
lab=VP}
N -2160 -390 -2160 -380 {
lab=VP}
N -1980 -320 -1980 -310 {
lab=#net4}
N -2070 -320 -2070 -310 {
lab=#net4}
N -1980 -390 -1980 -380 {
lab=VP}
N -2070 -390 -2070 -380 {
lab=VP}
N -1630 60 -1560 60 {
lab=#net3}
N -1700 60 -1630 60 {
lab=#net3}
N -2620 -350 -2530 -350 {
lab=Vbp}
N -2530 -350 -2440 -350 {
lab=Vbp}
N -2440 -350 -2350 -350 {
lab=Vbp}
N -2130 -350 -2040 -350 {
lab=Vbp}
N -2040 -350 -1950 -350 {
lab=Vbp}
N -1950 -350 -1860 -350 {
lab=Vbp}
N -1100 530 -1100 540 {
lab=VN}
N -1100 450 -1100 470 {
lab=#net5}
N -1100 370 -1100 390 {
lab=#net6}
N -1100 290 -1100 310 {
lab=#net7}
N -1070 260 -1060 260 {
lab=#net8}
N -1060 260 -1060 500 {
lab=#net8}
N -1070 420 -1060 420 {
lab=#net8}
N -1070 340 -1060 340 {
lab=#net8}
N -1070 500 -1060 500 {
lab=#net8}
N -830 90 -830 100 {
lab=#net1}
N -1100 90 -1100 100 {
lab=#net1}
N -830 20 -830 30 {
lab=#net2}
N -1100 20 -1100 30 {
lab=#net2}
N -920 90 -920 100 {
lab=#net1}
N -1010 90 -1010 100 {
lab=#net1}
N -920 20 -920 30 {
lab=#net2}
N -1010 20 -1010 30 {
lab=#net2}
N -1070 60 -980 60 {
lab=#net1}
N -980 60 -890 60 {
lab=#net1}
N -890 60 -800 60 {
lab=#net1}
N -830 -320 -830 -310 {
lab=#net2}
N -1100 -310 -830 -310 {
lab=#net2}
N -1100 -320 -1100 -310 {
lab=#net2}
N -1100 -390 -1100 -380 {
lab=VP}
N -1010 -390 -1010 -380 {
lab=VP}
N -920 -390 -920 -380 {
lab=VP}
N -920 -320 -920 -310 {
lab=#net2}
N -1010 -320 -1010 -310 {
lab=#net2}
N -800 60 -710 60 {
lab=#net1}
N -1100 100 -470 100 {
lab=#net1}
N -1100 20 -470 20 {
lab=#net2}
N -1100 -390 -830 -390 {
lab=VP}
N -1600 100 -1530 100 {
lab=#net3}
N -1600 60 -1600 100 {
lab=#net3}
N -1260 20 -1100 20 {
lab=#net2}
N -1100 100 -1100 230 {
lab=#net1}
N -1950 500 -1860 500 {
lab=#net4}
N -2380 -390 -2160 -390 {
lab=VP}
N -2350 -350 -2130 -350 {
lab=Vbp}
N -2380 -310 -2310 -310 {
lab=Vbp}
N -2310 -350 -2310 -310 {
lab=Vbp}
N -1860 500 -1500 500 {
lab=#net4}
N -1890 540 -1530 540 {
lab=VN}
N -1890 460 -1800 460 {
lab=#net4}
N -1800 460 -1800 500 {
lab=#net4}
N -1070 -350 -980 -350 {
lab=#net1}
N -980 -350 -890 -350 {
lab=#net1}
N -890 -350 -800 -350 {
lab=#net1}
N -1890 -390 -1100 -390 {
lab=VP}
N -1860 -350 -1820 -350 {
lab=Vbp}
N -1060 -310 -1060 20 {
lab=#net2}
N -2160 -310 -2160 460 {
lab=#net4}
N -1260 100 -1260 460 {
lab=#net3}
N -110 90 -110 100 {
lab=#net1}
N -380 90 -380 100 {
lab=#net1}
N -110 20 -110 30 {
lab=#net2}
N -380 20 -380 30 {
lab=#net2}
N -200 90 -200 100 {
lab=#net1}
N -290 90 -290 100 {
lab=#net1}
N -200 20 -200 30 {
lab=#net2}
N -290 20 -290 30 {
lab=#net2}
N -350 60 -260 60 {
lab=#net1}
N -260 60 -170 60 {
lab=#net1}
N -470 20 -110 20 {
lab=#net2}
N -470 100 -110 100 {
lab=#net1}
N -110 100 -50 100 {
lab=#net1}
N -50 60 -50 100 {
lab=#net1}
N -80 60 -50 60 {
lab=#net1}
N -50 -350 -50 60 {
lab=#net1}
N -800 -350 -50 -350 {
lab=#net1}
N -440 60 -350 60 {
lab=#net1}
N -170 60 -80 60 {
lab=#net1}
N 930 -710 970 -710 {
lab=#net9}
N 1330 -710 1370 -710 {
lab=#net10}
N 1430 -710 1440 -710 {
lab=VDD}
N 800 -750 800 -740 {
lab=Vbp}
N 800 -750 1500 -750 {
lab=Vbp}
N 1500 -750 1500 -740 {
lab=Vbp}
N 1400 -750 1400 -740 {
lab=Vbp}
N 1300 -750 1300 -740 {
lab=Vbp}
N 1200 -750 1200 -740 {
lab=Vbp}
N 1100 -750 1100 -740 {
lab=Vbp}
N 1000 -750 1000 -740 {
lab=Vbp}
N 900 -750 900 -740 {
lab=Vbp}
N 1260 -710 1270 -710 {
lab=#net11}
N 1260 -780 1260 -710 {
lab=#net11}
N 860 -780 1260 -780 {
lab=#net11}
N 860 -780 860 -710 {
lab=#net11}
N 860 -710 870 -710 {
lab=#net11}
N 1130 -710 1170 -710 {
lab=VDD}
N 1150 -800 1150 -710 {
lab=VDD}
N 1030 -710 1040 -710 {
lab=#net12}
N 1530 -710 1540 -710 {
lab=VDD}
N 760 -710 770 -710 {
lab=VDD}
N 760 -800 760 -710 {
lab=VDD}
N 1630 -550 1670 -550 {
lab=Vcn}
N 1730 -550 1770 -550 {
lab=#net13}
N 1830 -550 1870 -550 {
lab=Vcn}
N 1560 -550 1570 -550 {
lab=#net13}
N 1560 -550 1560 -480 {
lab=#net13}
N 1560 -480 1940 -480 {
lab=#net13}
N 1940 -550 1940 -480 {
lab=#net13}
N 1930 -550 1940 -550 {
lab=#net13}
N 1750 -550 1750 -480 {
lab=#net13}
N 1600 -590 1600 -580 {
lab=Vcn}
N 1600 -590 1900 -590 {
lab=Vcn}
N 1900 -590 1900 -580 {
lab=Vcn}
N 1800 -590 1800 -580 {
lab=Vcn}
N 1700 -590 1700 -580 {
lab=Vcn}
N 1650 -590 1650 -550 {
lab=Vcn}
N 1850 -590 1850 -550 {
lab=Vcn}
N 1460 -710 1470 -710 {
lab=#net14}
N 1230 -710 1240 -710 {
lab=#net14}
N 1460 -710 1460 -630 {
lab=#net14}
N 840 -630 1460 -630 {
lab=#net14}
N 840 -710 840 -630 {
lab=#net14}
N 830 -710 840 -710 {
lab=#net14}
N 1240 -710 1240 -630 {
lab=#net14}
N 1060 -710 1070 -710 {
lab=#net14}
N 1060 -710 1060 -630 {
lab=#net14}
N 1900 -590 1940 -590 {
lab=Vcn}
N 430 -330 470 -330 {
lab=#net15}
N 530 -330 570 -330 {
lab=#net16}
N 630 -330 670 -330 {
lab=#net15}
N 360 -330 370 -330 {
lab=#net16}
N 360 -330 360 -240 {
lab=#net16}
N 360 -240 740 -240 {
lab=#net16}
N 730 -330 740 -330 {
lab=#net16}
N 550 -330 550 -240 {
lab=#net16}
N 960 -330 970 -330 {
lab=#net16}
N 960 -240 1340 -240 {
lab=#net16}
N 1330 -330 1340 -330 {
lab=#net16}
N 1230 -330 1270 -330 {
lab=#net15}
N 1130 -330 1170 -330 {
lab=#net16}
N 1150 -330 1150 -240 {
lab=#net16}
N 1030 -330 1070 -330 {
lab=#net15}
N 740 -240 960 -240 {
lab=#net16}
N 1340 -240 1940 -240 {
lab=#net16}
N 1940 -330 1940 -240 {
lab=#net16}
N 1930 -330 1940 -330 {
lab=#net16}
N 1830 -330 1870 -330 {
lab=#net15}
N 1730 -330 1770 -330 {
lab=#net16}
N 1750 -330 1750 -240 {
lab=#net16}
N 1630 -330 1670 -330 {
lab=#net15}
N 1560 -330 1570 -330 {
lab=#net16}
N 1430 -330 1470 -330 {
lab=GND}
N 1340 -330 1370 -330 {
lab=#net16}
N 1530 -330 1560 -330 {
lab=#net16}
N 1550 -330 1550 -240 {
lab=#net16}
N 830 -330 870 -330 {
lab=GND}
N 740 -330 770 -330 {
lab=#net16}
N 930 -330 960 -330 {
lab=#net16}
N 750 -330 750 -240 {
lab=#net16}
N 950 -330 950 -240 {
lab=#net16}
N 1350 -330 1350 -240 {
lab=#net16}
N 400 -370 400 -360 {
lab=#net15}
N 400 -370 1900 -370 {
lab=#net15}
N 1900 -370 1900 -360 {
lab=#net15}
N 1800 -370 1800 -360 {
lab=#net15}
N 1700 -370 1700 -360 {
lab=#net15}
N 1600 -370 1600 -360 {
lab=#net15}
N 1500 -370 1500 -360 {
lab=#net15}
N 1400 -370 1400 -360 {
lab=#net15}
N 1300 -370 1300 -360 {
lab=#net15}
N 1200 -370 1200 -360 {
lab=#net15}
N 1100 -370 1100 -360 {
lab=#net15}
N 1000 -370 1000 -360 {
lab=#net15}
N 900 -370 900 -360 {
lab=#net15}
N 800 -370 800 -360 {
lab=#net15}
N 700 -370 700 -360 {
lab=#net15}
N 600 -370 600 -360 {
lab=#net15}
N 500 -370 500 -360 {
lab=#net15}
N 1250 -370 1250 -330 {
lab=#net15}
N 1050 -370 1050 -330 {
lab=#net15}
N 650 -370 650 -330 {
lab=#net15}
N 450 -370 450 -330 {
lab=#net15}
N 850 -330 850 -200 {
lab=GND}
N 1450 -330 1450 -200 {
lab=GND}
N 1650 -370 1650 -330 {
lab=#net15}
N 1850 -370 1850 -330 {
lab=#net15}
N 400 -920 400 -910 {
lab=#net17}
N 400 -910 1900 -910 {
lab=#net17}
N 1900 -920 1900 -910 {
lab=#net17}
N 430 -950 470 -950 {
lab=#net17}
N 530 -950 570 -950 {
lab=#net18}
N 630 -950 670 -950 {
lab=#net17}
N 360 -950 370 -950 {
lab=#net18}
N 360 -1040 360 -950 {
lab=#net18}
N 730 -950 770 -950 {
lab=#net18}
N 830 -950 870 -950 {
lab=VDD}
N 930 -950 970 -950 {
lab=#net18}
N 1030 -950 1070 -950 {
lab=#net17}
N 1130 -950 1170 -950 {
lab=#net18}
N 1230 -950 1270 -950 {
lab=#net17}
N 1330 -950 1370 -950 {
lab=#net18}
N 1430 -950 1470 -950 {
lab=VDD}
N 1530 -950 1570 -950 {
lab=#net18}
N 1630 -950 1670 -950 {
lab=#net17}
N 1730 -950 1770 -950 {
lab=#net18}
N 1830 -950 1870 -950 {
lab=#net17}
N 500 -920 500 -910 {
lab=#net17}
N 600 -920 600 -910 {
lab=#net17}
N 700 -920 700 -910 {
lab=#net17}
N 800 -920 800 -910 {
lab=#net17}
N 900 -920 900 -910 {
lab=#net17}
N 1000 -920 1000 -910 {
lab=#net17}
N 1100 -920 1100 -910 {
lab=#net17}
N 1200 -920 1200 -910 {
lab=#net17}
N 1300 -920 1300 -910 {
lab=#net17}
N 1400 -920 1400 -910 {
lab=#net17}
N 1500 -920 1500 -910 {
lab=#net17}
N 1600 -920 1600 -910 {
lab=#net17}
N 1700 -920 1700 -910 {
lab=#net17}
N 1800 -920 1800 -910 {
lab=#net17}
N 550 -1040 550 -950 {
lab=#net18}
N 360 -1040 1940 -1040 {
lab=#net18}
N 1940 -1040 1940 -950 {
lab=#net18}
N 1930 -950 1940 -950 {
lab=#net18}
N 1750 -1040 1750 -950 {
lab=#net18}
N 1550 -1040 1550 -950 {
lab=#net18}
N 1350 -1040 1350 -950 {
lab=#net18}
N 1150 -1040 1150 -950 {
lab=#net18}
N 950 -1040 950 -950 {
lab=#net18}
N 750 -1040 750 -950 {
lab=#net18}
N 850 -1090 850 -950 {
lab=VDD}
N 1450 -1090 1450 -950 {
lab=VDD}
N 450 -950 450 -910 {
lab=#net17}
N 650 -950 650 -910 {
lab=#net17}
N 1050 -950 1050 -910 {
lab=#net17}
N 1250 -950 1250 -910 {
lab=#net17}
N 1650 -950 1650 -910 {
lab=#net17}
N 1850 -950 1850 -910 {
lab=#net17}
N 800 -520 800 -510 {
lab=#net19}
N 1500 -520 1500 -510 {
lab=#net20}
N 900 -520 900 -510 {
lab=#net20}
N 1000 -520 1000 -510 {
lab=#net20}
N 1100 -520 1100 -510 {
lab=#net20}
N 1200 -520 1200 -510 {
lab=#net20}
N 1300 -520 1300 -510 {
lab=#net20}
N 1400 -520 1400 -510 {
lab=#net20}
N 1530 -550 1540 -550 {
lab=GND}
N 1540 -550 1540 -450 {
lab=GND}
N 760 -550 760 -450 {
lab=GND}
N 760 -550 770 -550 {
lab=GND}
N 1130 -550 1170 -550 {
lab=GND}
N 1150 -550 1150 -450 {
lab=GND}
N 1440 -550 1440 -450 {
lab=GND}
N 860 -550 870 -550 {
lab=#net21}
N 930 -550 970 -550 {
lab=#net22}
N 1430 -550 1440 -550 {
lab=GND}
N 1330 -550 1370 -550 {
lab=#net23}
N 1260 -550 1270 -550 {
lab=#net21}
N 830 -550 840 -550 {
lab=#net24}
N 1460 -550 1470 -550 {
lab=#net24}
N 1060 -550 1070 -550 {
lab=#net24}
N 1230 -550 1240 -550 {
lab=#net24}
N 1560 -710 1570 -710 {
lab=#net25}
N 1560 -790 1560 -710 {
lab=#net25}
N 1930 -710 1940 -710 {
lab=#net25}
N 1940 -790 1940 -710 {
lab=#net25}
N 1560 -790 1940 -790 {
lab=#net25}
N 1630 -710 1670 -710 {
lab=Vcp}
N 1730 -710 1770 -710 {
lab=#net25}
N 1750 -790 1750 -710 {
lab=#net25}
N 1830 -710 1870 -710 {
lab=Vcp}
N 1600 -680 1600 -670 {
lab=Vcp}
N 1600 -670 1900 -670 {
lab=Vcp}
N 1900 -680 1900 -670 {
lab=Vcp}
N 1800 -680 1800 -670 {
lab=Vcp}
N 1700 -680 1700 -670 {
lab=Vcp}
N 1650 -710 1650 -670 {
lab=Vcp}
N 1850 -710 1850 -670 {
lab=Vcp}
N -40 -710 -30 -710 {
lab=#net26}
N 330 -710 340 -710 {
lab=#net26}
N 30 -710 70 -710 {
lab=#net27}
N 130 -710 170 -710 {
lab=#net28}
N 230 -710 270 -710 {
lab=#net27}
N 0 -680 0 -670 {
lab=#net27}
N 0 -670 300 -670 {
lab=#net27}
N 300 -680 300 -670 {
lab=#net27}
N 100 -680 100 -670 {
lab=#net27}
N 200 -680 200 -670 {
lab=#net27}
N 250 -710 250 -670 {
lab=#net27}
N 50 -710 50 -670 {
lab=#net27}
N 630 -710 670 -710 {
lab=Vbp}
N 530 -710 570 -710 {
lab=#net29}
N 430 -710 470 -710 {
lab=Vbp}
N 700 -680 700 -670 {
lab=Vbp}
N 400 -670 700 -670 {
lab=Vbp}
N 400 -680 400 -670 {
lab=Vbp}
N 500 -680 500 -670 {
lab=Vbp}
N 600 -680 600 -670 {
lab=Vbp}
N 650 -710 650 -670 {
lab=Vbp}
N 450 -710 450 -670 {
lab=Vbp}
N 730 -710 740 -710 {
lab=#net29}
N 740 -790 740 -710 {
lab=#net29}
N 360 -790 740 -790 {
lab=#net29}
N 360 -790 360 -710 {
lab=#net29}
N 360 -710 370 -710 {
lab=#net29}
N 550 -790 550 -710 {
lab=#net29}
N 400 -590 400 -580 {
lab=Vbp}
N 400 -590 700 -590 {
lab=Vbp}
N 700 -590 700 -580 {
lab=Vbp}
N 600 -590 600 -580 {
lab=Vbp}
N 500 -590 500 -580 {
lab=Vbp}
N 430 -550 470 -550 {
lab=Vbp}
N 530 -550 570 -550 {
lab=#net30}
N 630 -550 670 -550 {
lab=Vbp}
N 360 -550 370 -550 {
lab=#net30}
N 360 -550 360 -460 {
lab=#net30}
N 360 -460 740 -460 {
lab=#net30}
N 740 -550 740 -460 {
lab=#net30}
N 730 -550 740 -550 {
lab=#net30}
N 550 -550 550 -460 {
lab=#net30}
N 450 -590 450 -550 {
lab=Vbp}
N 650 -590 650 -550 {
lab=Vbp}
N 550 -670 550 -590 {
lab=Vbp}
N 1060 -620 1060 -550 {
lab=#net24}
N 1240 -620 1240 -550 {
lab=#net24}
N 840 -620 840 -550 {
lab=#net24}
N 840 -620 1460 -620 {
lab=#net24}
N 900 -510 1500 -510 {
lab=#net20}
N 1460 -620 1460 -550 {
lab=#net24}
N 1260 -550 1260 -480 {
lab=#net21}
N 860 -480 1260 -480 {
lab=#net21}
N 860 -550 860 -480 {
lab=#net21}
N 1030 -550 1040 -550 {
lab=#net31}
N 1900 -670 1940 -670 {
lab=Vcp}
N 1440 -800 1440 -710 {
lab=VDD}
N 1540 -800 1540 -710 {
lab=VDD}
N 340 -790 340 -710 {}
N -40 -790 340 -790 {}
N -40 -790 -40 -710 {}
N 150 -790 150 -710 {}
N 800 -510 900 -510 {}
C {madvlsi/nmos3.sym} 400 -330 1 0 {name=M1a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 500 -330 1 0 {name=M1b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 600 -330 1 0 {name=M1c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 700 -330 1 0 {name=M1d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 -330 3 1 {name=M2a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 900 -330 3 1 {name=M2b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1400 -330 3 1 {name=M2c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1500 -330 3 1 {name=M2d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 900 -710 1 0 {name=M3a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1000 -710 1 0 {name=M3b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1300 -710 1 0 {name=M3c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1400 -710 1 0 {name=M3d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 800 -710 1 0 {name=M4a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1100 -710 1 0 {name=M4b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1200 -710 1 0 {name=M4c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1500 -710 1 0 {name=M4d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} -2110 -390 3 0 {name=p7 lab=VP}
C {devices/iopin.sym} -2110 540 1 0 {name=p3 lab=VN}
C {madvlsi/pmos3.sym} 700 -710 3 0 {name=M11a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 600 -710 3 0 {name=M11b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 500 -710 3 0 {name=M11c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 400 -710 3 0 {name=M11d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1600 -550 1 0 {name=M5a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1700 -550 1 0 {name=M5b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1800 -550 1 0 {name=M5c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1900 -550 1 0 {name=M5d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 900 -550 3 0 {name=M8a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1000 -550 3 0 {name=M8b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1300 -550 3 0 {name=M8c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1400 -550 3 0 {name=M8d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 400 -950 1 1 {name=M6a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 500 -950 1 1 {name=M6b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 600 -950 1 1 {name=M6c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 700 -950 1 1 {name=M6d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 800 -950 1 1 {name=M7a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 900 -950 1 1 {name=M7b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1400 -950 1 1 {name=M7c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1500 -950 1 1 {name=M7d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1900 -710 1 1 {name=M10d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1800 -710 1 1 {name=M10c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1700 -710 1 1 {name=M10b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1600 -710 1 1 {name=M10a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 -550 3 0 {name=M9a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1100 -550 3 0 {name=M9b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1200 -550 3 0 {name=M9c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1500 -550 3 0 {name=M9d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 400 -550 1 0 {name=M12a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 500 -550 1 0 {name=M12b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 600 -550 1 0 {name=M12c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 700 -550 1 0 {name=M12d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 300 -710 1 1 {name=M13d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 200 -710 1 1 {name=M13c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 100 -710 1 1 {name=M13b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 0 -710 1 1 {name=M13a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/opin.sym} 1940 -670 2 1 {name=p6 lab=Vcp}
C {devices/iopin.sym} 700 -670 0 0 {name=p5 lab=Vbp}
C {devices/opin.sym} 1940 -590 0 0 {name=p1 lab=Vcn}
C {devices/opin.sym} 700 -590 2 1 {name=p2 lab=Vb}
C {madvlsi/nmos3.sym} 1000 -330 1 0 {name=M1e
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1100 -330 1 0 {name=M1f
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1200 -330 1 0 {name=M1g
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1300 -330 1 0 {name=M1h
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1000 -950 1 1 {name=M6e
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1100 -950 1 1 {name=M6f
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1200 -950 1 1 {name=M6g
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1300 -950 1 1 {name=M6h
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2310 -310 2 0 {name=p4 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} 1350 -750 1 0 {name=p8 sig_type=std_logic lab=Vbp}
C {madvlsi/nmos3.sym} 1600 -330 1 0 {name=M1i
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1700 -330 1 0 {name=M1j
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1800 -330 1 0 {name=M1k
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1900 -330 1 0 {name=M1l
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1600 -950 1 1 {name=M6i
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1700 -950 1 1 {name=M6j
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1800 -950 1 1 {name=M6k
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1900 -950 1 1 {name=M6l
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1150 -800 0 0 {name=l3 lab=VDD}
C {madvlsi/vdd.sym} 760 -800 0 0 {name=l4 lab=VDD}
C {madvlsi/gnd.sym} 850 -200 0 0 {name=l5 lab=GND}
C {madvlsi/gnd.sym} 1450 -200 0 0 {name=l6 lab=GND}
C {madvlsi/vdd.sym} 850 -1090 0 0 {name=l7 lab=VDD}
C {madvlsi/vdd.sym} 1450 -1090 0 0 {name=l8 lab=VDD}
C {madvlsi/gnd.sym} 1540 -450 0 0 {name=l9 lab=GND}
C {madvlsi/gnd.sym} 760 -450 0 0 {name=l10 lab=GND}
C {madvlsi/gnd.sym} 1150 -450 0 0 {name=l11 lab=GND}
C {madvlsi/gnd.sym} 1440 -450 0 0 {name=l12 lab=GND}
C {madvlsi/vdd.sym} 1440 -800 0 0 {name=l1 lab=VDD}
C {madvlsi/vdd.sym} 1540 -800 0 0 {name=l2 lab=VDD}
