v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -2380 -390 -2380 -380 {
lab=VP}
N -2650 -390 -2380 -390 {
lab=VP}
N -2650 -390 -2650 -380 {
lab=VP}
N -2380 -320 -2380 -310 {
lab=Vbp}
N -2650 -310 -2380 -310 {
lab=Vbp}
N -2650 -320 -2650 -310 {
lab=Vbp}
N -2470 -390 -2470 -380 {
lab=VP}
N -2560 -390 -2560 -380 {
lab=VP}
N -2470 -320 -2470 -310 {
lab=Vbp}
N -2560 -320 -2560 -310 {
lab=Vbp}
N -470 90 -470 100 {
lab=#net1}
N -740 90 -740 100 {
lab=#net1}
N -470 20 -470 30 {
lab=#net2}
N -740 20 -740 30 {
lab=#net2}
N -560 90 -560 100 {
lab=#net1}
N -650 90 -650 100 {
lab=#net1}
N -560 20 -560 30 {
lab=#net2}
N -650 20 -650 30 {
lab=#net2}
N -710 60 -620 60 {
lab=#net1}
N -620 60 -530 60 {
lab=#net1}
N -530 60 -440 60 {
lab=#net1}
N -830 -390 -830 -380 {
lab=VP}
N -1530 20 -1530 30 {
lab=#net2}
N -1530 20 -1260 20 {
lab=#net2}
N -1260 20 -1260 30 {
lab=#net2}
N -1530 90 -1530 100 {
lab=Vcp}
N -1530 100 -1260 100 {
lab=Vcp}
N -1260 90 -1260 100 {
lab=Vcp}
N -1440 20 -1440 30 {
lab=#net2}
N -1350 20 -1350 30 {
lab=#net2}
N -1440 90 -1440 100 {
lab=Vcp}
N -1350 90 -1350 100 {
lab=Vcp}
N -1380 60 -1290 60 {
lab=Vcp}
N -1470 60 -1380 60 {
lab=Vcp}
N -1560 60 -1470 60 {
lab=Vcp}
N -1260 460 -1260 470 {
lab=Vcp}
N -1530 460 -1260 460 {
lab=Vcp}
N -1530 460 -1530 470 {
lab=Vcp}
N -1260 530 -1260 540 {
lab=VN}
N -1530 540 -1260 540 {
lab=VN}
N -1530 530 -1530 540 {
lab=VN}
N -1350 530 -1350 540 {
lab=VN}
N -1440 530 -1440 540 {
lab=VN}
N -1350 460 -1350 470 {
lab=Vcp}
N -1440 460 -1440 470 {
lab=Vcp}
N -1410 500 -1320 500 {
lab=Vb}
N -1500 500 -1410 500 {
lab=Vb}
N -1320 500 -1230 500 {
lab=Vb}
N -1260 540 -1100 540 {
lab=VN}
N -1890 460 -1890 470 {
lab=Vb}
N -2160 460 -1890 460 {
lab=Vb}
N -2160 460 -2160 470 {
lab=Vb}
N -1890 530 -1890 540 {
lab=VN}
N -2160 540 -1890 540 {
lab=VN}
N -2160 530 -2160 540 {
lab=VN}
N -1980 530 -1980 540 {
lab=VN}
N -2070 530 -2070 540 {
lab=VN}
N -1980 460 -1980 470 {
lab=Vb}
N -2070 460 -2070 470 {
lab=Vb}
N -2040 500 -1950 500 {
lab=Vb}
N -2130 500 -2040 500 {
lab=Vb}
N -1890 -320 -1890 -310 {
lab=Vb}
N -2160 -310 -1890 -310 {
lab=Vb}
N -2160 -320 -2160 -310 {
lab=Vb}
N -1890 -390 -1890 -380 {
lab=VP}
N -2160 -390 -1890 -390 {
lab=VP}
N -2160 -390 -2160 -380 {
lab=VP}
N -1980 -320 -1980 -310 {
lab=Vb}
N -2070 -320 -2070 -310 {
lab=Vb}
N -1980 -390 -1980 -380 {
lab=VP}
N -2070 -390 -2070 -380 {
lab=VP}
N -1630 60 -1560 60 {
lab=Vcp}
N -1700 60 -1630 60 {
lab=Vcp}
N -2620 -350 -2530 -350 {
lab=Vbp}
N -2530 -350 -2440 -350 {
lab=Vbp}
N -2440 -350 -2350 -350 {
lab=Vbp}
N -2130 -350 -2040 -350 {
lab=Vbp}
N -2040 -350 -1950 -350 {
lab=Vbp}
N -1950 -350 -1860 -350 {
lab=Vbp}
N -1100 530 -1100 540 {
lab=VN}
N -1100 450 -1100 470 {
lab=#net3}
N -1100 370 -1100 390 {
lab=#net4}
N -1100 290 -1100 310 {
lab=#net5}
N -1070 260 -1060 260 {
lab=#net6}
N -1060 260 -1060 500 {
lab=#net6}
N -1070 420 -1060 420 {
lab=#net6}
N -1070 340 -1060 340 {
lab=#net6}
N -1070 500 -1060 500 {
lab=#net6}
N -830 90 -830 100 {
lab=#net1}
N -1100 90 -1100 100 {
lab=#net1}
N -830 20 -830 30 {
lab=#net2}
N -1100 20 -1100 30 {
lab=#net2}
N -920 90 -920 100 {
lab=#net1}
N -1010 90 -1010 100 {
lab=#net1}
N -920 20 -920 30 {
lab=#net2}
N -1010 20 -1010 30 {
lab=#net2}
N -1070 60 -980 60 {
lab=#net1}
N -980 60 -890 60 {
lab=#net1}
N -890 60 -800 60 {
lab=#net1}
N -830 -320 -830 -310 {
lab=#net2}
N -1100 -310 -830 -310 {
lab=#net2}
N -1100 -320 -1100 -310 {
lab=#net2}
N -1100 -390 -1100 -380 {
lab=VP}
N -1010 -390 -1010 -380 {
lab=VP}
N -920 -390 -920 -380 {
lab=VP}
N -920 -320 -920 -310 {
lab=#net2}
N -1010 -320 -1010 -310 {
lab=#net2}
N -800 60 -710 60 {
lab=#net1}
N -1100 100 -470 100 {
lab=#net1}
N -1100 20 -470 20 {
lab=#net2}
N -1100 -390 -830 -390 {
lab=VP}
N -1600 100 -1530 100 {
lab=Vcp}
N -1600 60 -1600 100 {
lab=Vcp}
N -1260 20 -1100 20 {
lab=#net2}
N -1100 100 -1100 230 {
lab=#net1}
N -1950 500 -1860 500 {
lab=Vb}
N -2380 -390 -2160 -390 {
lab=VP}
N -2350 -350 -2130 -350 {
lab=Vbp}
N -2380 -310 -2310 -310 {
lab=Vbp}
N -2310 -350 -2310 -310 {
lab=Vbp}
N -1860 500 -1500 500 {
lab=Vb}
N -1890 540 -1530 540 {
lab=VN}
N -1890 460 -1800 460 {
lab=Vb}
N -1800 460 -1800 500 {
lab=Vb}
N -1070 -350 -980 -350 {
lab=#net1}
N -980 -350 -890 -350 {
lab=#net1}
N -890 -350 -800 -350 {
lab=#net1}
N -1890 -390 -1100 -390 {
lab=VP}
N -1860 -350 -1820 -350 {
lab=Vbp}
N -1060 -310 -1060 20 {
lab=#net2}
N -2160 -310 -2160 460 {
lab=Vb}
N -1260 100 -1260 460 {
lab=Vcp}
N -110 90 -110 100 {
lab=#net1}
N -380 90 -380 100 {
lab=#net1}
N -110 20 -110 30 {
lab=#net2}
N -380 20 -380 30 {
lab=#net2}
N -200 90 -200 100 {
lab=#net1}
N -290 90 -290 100 {
lab=#net1}
N -200 20 -200 30 {
lab=#net2}
N -290 20 -290 30 {
lab=#net2}
N -350 60 -260 60 {
lab=#net1}
N -260 60 -170 60 {
lab=#net1}
N -470 20 -110 20 {
lab=#net2}
N -470 100 -110 100 {
lab=#net1}
N -110 100 -50 100 {
lab=#net1}
N -50 60 -50 100 {
lab=#net1}
N -80 60 -50 60 {
lab=#net1}
N -50 -350 -50 60 {
lab=#net1}
N -800 -350 -50 -350 {
lab=#net1}
N -440 60 -350 60 {
lab=#net1}
N -170 60 -80 60 {
lab=#net1}
N 1320 -710 1360 -710 {
lab=#net7}
N 1720 -710 1760 -710 {
lab=#net8}
N 1820 -710 1830 -710 {
lab=VDD}
N 1830 -780 1830 -710 {
lab=VDD}
N 1190 -750 1190 -740 {
lab=Vbp}
N 1190 -750 1890 -750 {
lab=Vbp}
N 1890 -750 1890 -740 {
lab=Vbp}
N 1790 -750 1790 -740 {
lab=Vbp}
N 1690 -750 1690 -740 {
lab=Vbp}
N 1590 -750 1590 -740 {
lab=Vbp}
N 1490 -750 1490 -740 {
lab=Vbp}
N 1390 -750 1390 -740 {
lab=Vbp}
N 1290 -750 1290 -740 {
lab=Vbp}
N 1650 -710 1660 -710 {
lab=#net9}
N 1650 -780 1650 -710 {
lab=#net9}
N 1250 -780 1650 -780 {
lab=#net9}
N 1250 -780 1250 -710 {
lab=#net9}
N 1250 -710 1260 -710 {
lab=#net9}
N 1520 -710 1560 -710 {
lab=VDD}
N 1540 -800 1540 -710 {
lab=VDD}
N 1420 -710 1430 -710 {
lab=#net10}
N 1920 -710 1930 -710 {
lab=VDD}
N 1150 -710 1160 -710 {
lab=VDD}
N 1150 -800 1150 -710 {
lab=VDD}
N 1930 -790 1930 -710 {
lab=VDD}
N 1620 -550 1660 -550 {
lab=Vcn}
N 1720 -550 1760 -550 {
lab=GND}
N 1820 -550 1860 -550 {
lab=Vcn}
N 1550 -550 1560 -550 {
lab=GND}
N 1550 -550 1550 -480 {
lab=GND}
N 1550 -480 1930 -480 {
lab=GND}
N 1930 -550 1930 -480 {
lab=GND}
N 1920 -550 1930 -550 {
lab=GND}
N 1740 -550 1740 -480 {
lab=GND}
N 1590 -590 1590 -580 {
lab=Vcn}
N 1590 -590 1890 -590 {
lab=Vcn}
N 1890 -590 1890 -580 {
lab=Vcn}
N 1790 -590 1790 -580 {
lab=Vcn}
N 1690 -590 1690 -580 {
lab=Vcn}
N 1640 -590 1640 -550 {
lab=Vcn}
N 1840 -590 1840 -550 {
lab=Vcn}
N 1850 -710 1860 -710 {
lab=Vcn}
N 1620 -710 1630 -710 {
lab=Vcn}
N 1850 -710 1850 -630 {
lab=Vcn}
N 1230 -630 1850 -630 {
lab=Vcn}
N 1230 -710 1230 -630 {
lab=Vcn}
N 1220 -710 1230 -710 {
lab=Vcn}
N 1630 -710 1630 -630 {
lab=Vcn}
N 1450 -710 1460 -710 {
lab=Vcn}
N 1450 -710 1450 -630 {
lab=Vcn}
N 1740 -630 1740 -590 {
lab=Vcn}
N 1890 -590 1930 -590 {
lab=Vcn}
N 420 -330 460 -330 {
lab=#net10}
N 520 -330 560 -330 {
lab=#net11}
N 620 -330 660 -330 {
lab=#net10}
N 350 -330 360 -330 {
lab=#net11}
N 350 -330 350 -240 {
lab=#net11}
N 350 -240 730 -240 {
lab=#net11}
N 720 -330 730 -330 {
lab=#net11}
N 540 -330 540 -240 {
lab=#net11}
N 950 -330 960 -330 {
lab=#net11}
N 950 -240 1330 -240 {
lab=#net11}
N 1320 -330 1330 -330 {
lab=#net11}
N 1220 -330 1260 -330 {
lab=#net10}
N 1120 -330 1160 -330 {
lab=#net11}
N 1140 -330 1140 -240 {
lab=#net11}
N 1020 -330 1060 -330 {
lab=#net10}
N 730 -240 950 -240 {
lab=#net11}
N 1330 -240 1930 -240 {
lab=#net11}
N 1930 -330 1930 -240 {
lab=#net11}
N 1920 -330 1930 -330 {
lab=#net11}
N 1820 -330 1860 -330 {
lab=#net10}
N 1720 -330 1760 -330 {
lab=#net11}
N 1740 -330 1740 -240 {
lab=#net11}
N 1620 -330 1660 -330 {
lab=#net10}
N 1550 -330 1560 -330 {
lab=#net11}
N 1420 -330 1460 -330 {
lab=GND}
N 1330 -330 1360 -330 {
lab=#net11}
N 1520 -330 1550 -330 {
lab=#net11}
N 1540 -330 1540 -240 {
lab=#net11}
N 820 -330 860 -330 {
lab=GND}
N 730 -330 760 -330 {
lab=#net11}
N 920 -330 950 -330 {
lab=#net11}
N 740 -330 740 -240 {
lab=#net11}
N 940 -330 940 -240 {
lab=#net11}
N 1340 -330 1340 -240 {
lab=#net11}
N 390 -370 390 -360 {
lab=#net10}
N 390 -370 1890 -370 {
lab=#net10}
N 1890 -370 1890 -360 {
lab=#net10}
N 1790 -370 1790 -360 {
lab=#net10}
N 1690 -370 1690 -360 {
lab=#net10}
N 1590 -370 1590 -360 {
lab=#net10}
N 1490 -370 1490 -360 {
lab=#net10}
N 1390 -370 1390 -360 {
lab=#net10}
N 1290 -370 1290 -360 {
lab=#net10}
N 1190 -370 1190 -360 {
lab=#net10}
N 1090 -370 1090 -360 {
lab=#net10}
N 990 -370 990 -360 {
lab=#net10}
N 890 -370 890 -360 {
lab=#net10}
N 790 -370 790 -360 {
lab=#net10}
N 690 -370 690 -360 {
lab=#net10}
N 590 -370 590 -360 {
lab=#net10}
N 490 -370 490 -360 {
lab=#net10}
N 1240 -370 1240 -330 {
lab=#net10}
N 1040 -370 1040 -330 {
lab=#net10}
N 640 -370 640 -330 {
lab=#net10}
N 440 -370 440 -330 {
lab=#net10}
N 840 -330 840 -200 {
lab=GND}
N 1440 -330 1440 -200 {
lab=GND}
N 1640 -370 1640 -330 {
lab=#net10}
N 1840 -370 1840 -330 {
lab=#net10}
N 1430 -710 1430 -370 {
lab=#net10}
N 400 -920 400 -910 {
lab=#net12}
N 400 -910 1900 -910 {
lab=#net12}
N 1900 -920 1900 -910 {
lab=#net12}
N 430 -950 470 -950 {
lab=#net12}
N 530 -950 570 -950 {
lab=#net13}
N 630 -950 670 -950 {
lab=#net12}
N 360 -950 370 -950 {
lab=#net13}
N 360 -1040 360 -950 {
lab=#net13}
N 730 -950 770 -950 {
lab=#net13}
N 830 -950 870 -950 {
lab=VDD}
N 930 -950 970 -950 {
lab=#net13}
N 1030 -950 1070 -950 {
lab=#net12}
N 1130 -950 1170 -950 {
lab=#net13}
N 1230 -950 1270 -950 {
lab=#net12}
N 1330 -950 1370 -950 {
lab=#net13}
N 1430 -950 1470 -950 {
lab=VDD}
N 1530 -950 1570 -950 {
lab=#net13}
N 1630 -950 1670 -950 {
lab=#net12}
N 1730 -950 1770 -950 {
lab=#net13}
N 1830 -950 1870 -950 {
lab=#net12}
N 500 -920 500 -910 {
lab=#net12}
N 600 -920 600 -910 {
lab=#net12}
N 700 -920 700 -910 {
lab=#net12}
N 800 -920 800 -910 {
lab=#net12}
N 900 -920 900 -910 {
lab=#net12}
N 1000 -920 1000 -910 {
lab=#net12}
N 1100 -920 1100 -910 {
lab=#net12}
N 1200 -920 1200 -910 {
lab=#net12}
N 1300 -920 1300 -910 {
lab=#net12}
N 1400 -920 1400 -910 {
lab=#net12}
N 1500 -920 1500 -910 {
lab=#net12}
N 1600 -920 1600 -910 {
lab=#net12}
N 1700 -920 1700 -910 {
lab=#net12}
N 1800 -920 1800 -910 {
lab=#net12}
N 550 -1040 550 -950 {
lab=#net13}
N 360 -1040 1940 -1040 {
lab=#net13}
N 1940 -1040 1940 -950 {
lab=#net13}
N 1930 -950 1940 -950 {
lab=#net13}
N 1750 -1040 1750 -950 {
lab=#net13}
N 1550 -1040 1550 -950 {
lab=#net13}
N 1350 -1040 1350 -950 {
lab=#net13}
N 1150 -1040 1150 -950 {
lab=#net13}
N 950 -1040 950 -950 {
lab=#net13}
N 750 -1040 750 -950 {
lab=#net13}
N 850 -1090 850 -950 {
lab=VDD}
N 1450 -1090 1450 -950 {
lab=VDD}
N 450 -950 450 -910 {
lab=#net12}
N 650 -950 650 -910 {
lab=#net12}
N 1050 -950 1050 -910 {
lab=#net12}
N 1250 -950 1250 -910 {
lab=#net12}
N 1650 -950 1650 -910 {
lab=#net12}
N 1850 -950 1850 -910 {
lab=#net12}
N 400 -520 400 -510 {
lab=#net14}
N 400 -510 1110 -510 {
lab=#net14}
N 1110 -520 1110 -510 {
lab=#net14}
N 500 -520 500 -510 {
lab=#net14}
N 600 -520 600 -510 {
lab=#net14}
N 700 -520 700 -510 {
lab=#net14}
N 800 -520 800 -510 {
lab=#net14}
N 900 -520 900 -510 {
lab=#net14}
N 1000 -520 1000 -510 {
lab=#net14}
N 1140 -550 1150 -550 {
lab=GND}
N 1150 -550 1150 -450 {
lab=GND}
N 360 -550 360 -450 {
lab=GND}
N 360 -550 370 -550 {
lab=GND}
N 730 -550 770 -550 {
lab=GND}
N 750 -550 750 -450 {
lab=GND}
N 460 -550 460 -450 {
lab=GND}
N 460 -550 470 -550 {}
N 530 -550 570 -550 {}
N 630 -550 630 -490 {}
N 1030 -550 1040 -550 {}
N 1040 -550 1040 -490 {}
N 630 -490 1040 -490 {}
N 930 -550 970 -550 {}
N 860 -550 870 -550 {}
N 430 -550 440 -550 {}
N 440 -630 440 -550 {}
N 440 -630 1070 -630 {}
N 1070 -630 1070 -550 {}
N 1070 -550 1080 -550 {}
N 660 -550 670 -550 {}
N 660 -630 660 -550 {}
N 830 -550 840 -550 {}
N 840 -630 840 -550 {}
N 360 -710 370 -710 {}
N 360 -790 360 -710 {}
N 730 -710 740 -710 {}
N 740 -790 740 -710 {}
N 360 -790 740 -790 {}
N 430 -710 470 -710 {}
N 530 -710 570 -710 {}
N 550 -790 550 -710 {}
N 630 -710 670 -710 {}
N 400 -680 400 -670 {}
N 400 -670 700 -670 {}
N 700 -680 700 -670 {}
N 600 -680 600 -670 {}
N 500 -680 500 -670 {}
N 450 -710 450 -670 {}
N 650 -710 650 -670 {}
N 550 -670 550 -630 {}
N 1930 -480 1930 -330 {}
N 360 -950 360 -790 {}
N 860 -910 860 -550 {}
C {madvlsi/nmos3.sym} 390 -330 1 0 {name=M1a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 490 -330 1 0 {name=M1b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 590 -330 1 0 {name=M1c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 690 -330 1 0 {name=M1d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 790 -330 3 1 {name=M2a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 890 -330 3 1 {name=M2b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1390 -330 3 1 {name=M2c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1490 -330 3 1 {name=M2d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1290 -710 1 0 {name=M3a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1390 -710 1 0 {name=M3b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1690 -710 1 0 {name=M3c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1790 -710 1 0 {name=M3d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1190 -710 1 0 {name=M4a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1490 -710 1 0 {name=M4b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1590 -710 1 0 {name=M4c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1890 -710 1 0 {name=M4d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} -2110 -390 3 0 {name=p7 lab=VP}
C {devices/iopin.sym} -2110 540 1 0 {name=p3 lab=VN}
C {madvlsi/pmos3.sym} -2380 -350 2 0 {name=M11a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -2470 -350 2 0 {name=M11b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -2560 -350 2 0 {name=M11c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -2650 -350 2 0 {name=M11d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1590 -550 1 0 {name=M5a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1690 -550 1 0 {name=M5b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1790 -550 1 0 {name=M5c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1890 -550 1 0 {name=M5d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 500 -550 3 0 {name=M8a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 600 -550 3 0 {name=M8b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 900 -550 3 0 {name=M8c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1000 -550 3 0 {name=M8d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 400 -950 1 1 {name=M6a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 500 -950 1 1 {name=M6b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 600 -950 1 1 {name=M6c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 700 -950 1 1 {name=M6d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 800 -950 1 1 {name=M7a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 900 -950 1 1 {name=M7b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1400 -950 1 1 {name=M7c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1500 -950 1 1 {name=M7d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 700 -710 1 1 {name=M10d
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 600 -710 1 1 {name=M10c
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 500 -710 1 1 {name=M10b
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 400 -710 1 1 {name=M10a
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 400 -550 3 0 {name=M9a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 700 -550 3 0 {name=M9b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 800 -550 3 0 {name=M9c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1110 -550 3 0 {name=M9d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1890 500 2 0 {name=M12a
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -1980 500 2 0 {name=M12b
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -2070 500 2 0 {name=M12c
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -2160 500 2 0 {name=M12d
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1890 -350 0 1 {name=M1
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -1980 -350 0 1 {name=M2
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -2070 -350 0 1 {name=M3
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -2160 -350 0 1 {name=M4
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/opin.sym} -1700 60 0 1 {name=p6 lab=Vcp}
C {devices/iopin.sym} -1820 -350 0 0 {name=p5 lab=Vbp}
C {devices/opin.sym} 1930 -590 0 0 {name=p1 lab=Vcn}
C {devices/opin.sym} -1800 460 2 1 {name=p2 lab=Vb}
C {madvlsi/nmos3.sym} 990 -330 1 0 {name=M1e
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1090 -330 1 0 {name=M1f
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1190 -330 1 0 {name=M1g
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1290 -330 1 0 {name=M1h
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1000 -950 1 1 {name=M6e
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1100 -950 1 1 {name=M6f
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1200 -950 1 1 {name=M6g
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1300 -950 1 1 {name=M6h
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} -2310 -310 2 0 {name=p4 sig_type=std_logic lab=Vbp}
C {devices/lab_pin.sym} 1740 -750 1 0 {name=p8 sig_type=std_logic lab=Vbp}
C {madvlsi/nmos3.sym} 1590 -330 1 0 {name=M1i
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1690 -330 1 0 {name=M1j
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1790 -330 1 0 {name=M1k
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1890 -330 1 0 {name=M1l
L=0.5
W=3
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1600 -950 1 1 {name=M6i
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1700 -950 1 1 {name=M6j
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1800 -950 1 1 {name=M6k
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1900 -950 1 1 {name=M6l
L=0.5
W=3
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 1830 -780 0 0 {name=l1 lab=VDD}
C {madvlsi/vdd.sym} 1930 -790 0 0 {name=l2 lab=VDD}
C {madvlsi/vdd.sym} 1540 -800 0 0 {name=l3 lab=VDD}
C {madvlsi/vdd.sym} 1150 -800 0 0 {name=l4 lab=VDD}
C {madvlsi/gnd.sym} 840 -200 0 0 {name=l5 lab=GND}
C {madvlsi/gnd.sym} 1440 -200 0 0 {name=l6 lab=GND}
C {madvlsi/vdd.sym} 850 -1090 0 0 {name=l7 lab=VDD}
C {madvlsi/vdd.sym} 1450 -1090 0 0 {name=l8 lab=VDD}
C {madvlsi/gnd.sym} 1150 -450 0 0 {name=l9 lab=GND}
C {madvlsi/gnd.sym} 360 -450 0 0 {name=l10 lab=GND}
C {madvlsi/gnd.sym} 750 -450 0 0 {name=l11 lab=GND}
C {madvlsi/gnd.sym} 460 -450 0 0 {name=l12 lab=GND}
